## boards/shields/macrov4/Kconfig.defconfig
```kconfig
if SHIELD_MACROV4

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "MACROv4"

endif
```
